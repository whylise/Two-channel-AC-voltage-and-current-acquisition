# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FT_Data_Center +hex
  AfterMake: F:\MDK\mdk555\ARM\ARMCC\bin\fromelf.exe --bin -o ..\OBJ\FT_Data_Center.bin ..\OBJ\FT_Data_Center.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\CRC;..\HARDWARE\FATAI;..\HARDWARE\WDG;..\HARDWARE\EEPROM;..\MD5;..\SIM800C;..\LCD1602;..\EEPROM;..\WDG
  memory RVCT4: ROM 0x8002800 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c REALTIME.c system_stm32f10x.c main_task.c GSM.c ASSIT.c PC.c PC_ASSIT.c
  group SIM800C
    ../SIM800C/: http.c http_api.c sim800c.c sms.c hj212.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CRC/: crc16.c
    ../HARDWARE/FATAI/: recevice.c
  group WDG
    ../WDG/: wdg.c
  group MD5
    ../MD5/: MD5.c
  group LCD1602
    ../LCD1602/: LCD.c
  group EEPROM
    ../EEPROM/: eeporm.c init_flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_flash.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../: README.TXT
